# Keil uVision project medical.uvprojx, settings and files
target UCOSIII移植 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UCOSIII移植 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\src\main;..\src\system\delay;..\src\system\sys;..\src\system\usart;..\lib\CMSIS\CoreSupport;..\lib\STM32F10x_StdPeriph_Driver\inc;..\lib\UCOSIII\uC-CPU;..\lib\UCOSIII\uC-LIB;..\lib\UCOSIII\uCOS-III;..\lib\UCOSIII\UCOS_BSP;..\lib\UCOSIII\uCOS_CONFIG;..\lib\UCOSIII\uCOS-III\Source;..\lib\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\lib\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\lib\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\src\drivers\inc;..\src\system\delay;..\src\system\sys;..\src\system\usart;..\lib\math\inc;..\src\user
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ../src/main/: main.c stm32f10x_it.c system_stm32f10x.c
  group drivers
    ../src/drivers/src/: beep.c led.c oled.c mpu6050.c inv_mpu_dmp_motion_driver.c inv_mpu.c iic.c adc.c key.c oledbmp.c hc05.c
  group startup
    ../lib/CMSIS/CoreSupport/: core_cm3.c
    ../lib/CMSIS/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group ucos_bsp
    ../lib/UCOSIII/UCOS_BSP/: bsp.c
  group ucos_cpu
    ../lib/UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_a.asm cpu_c.c
    ../lib/UCOSIII/uC-CPU/: cpu_core.c
  group ucos_lib
    ../lib/UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../lib/UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group ucos_core
    ../lib/UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group ucos_port
    ../lib/UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu_a.s os_cpu.h
  group ucos_config
    ../lib/UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group STM32F10x_StdPeriph_Driver
    ../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group system
    ../src/system/delay/: delay.c
    ../src/system/sys/: sys.c
    ../src/system/usart/: usart.c
  group math
    ../lib/math/src/: mymath.c
  group user
    ../src/user/: user.c
